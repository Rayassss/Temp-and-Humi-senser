# Keil uVision project 51_DHT21.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 51_DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\YL-47测试程序
  group Source Group 1
    ./: 2.c
