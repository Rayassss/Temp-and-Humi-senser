# Keil uVision project project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 温湿度传感器V1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User
  group User
    ./User/: Main.c
  group Hardware
    ./Hardware/: Key.c Uart.c Led.c DHT11.c DS1302.c Lcd.c
  group System
    ./System/: Delay.c Server.c
